# Keil uVision project p.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: p
  c flags: Optim=1
  group Source Group 1
    ./: mul.s mul32.s sumofarray.s findmin.s lab7.s lab8.s
